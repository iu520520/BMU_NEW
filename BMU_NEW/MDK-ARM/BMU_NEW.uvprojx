# Keil uVision project BMU_NEW.uvprojx, settings and files
target BMU_NEW (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G455VEL7 Nationstech
  pack: Nations.N32G45x_DFP.1.3.0
  cpu: IRAM1(0x20000000,0x24000) IROM1(0x08000000,0x80000) CPUTYPE(Cortex-M4) FPU2 CLOCK(12000000) ELITTLE
  output: BMU_NEW +hex
  AfterMake: fromelf --bin --output=.\bin\BMU_NEW.bin .\Objects\BMU_NEW.axf
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: N32G45X, USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c include: ..\USER\inc;..\Driver\CMSIS\core;..\Driver\CMSIS\device;..\Driver\n32g45x_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x08000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group STARTUP
    ../Driver/CMSIS/device/startup/: startup_n32g45x.s
  group CMSIS
    ../Driver/CMSIS/device/: system_n32g45x.c
  group USER
    ../USER/src/: main.c n32g45x_it.c n32g45x_cfg.c
  group FWLB
    ../Driver/n32g45x_std_periph_driver/src/: n32g45x_flash.c n32g45x_dbg.c n32g45x_rcc.c misc.c n32g45x_dma.c n32g45x_gpio.c n32g45x_usart.c n32g45x_can.c
